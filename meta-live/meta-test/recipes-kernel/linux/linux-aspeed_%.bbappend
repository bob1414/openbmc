FILESEXTRAPATHS_prepend_${MACHINE} := "${THISDIR}/${PN}:"
SRC_URI += "file://${MACHINE}.cfg"

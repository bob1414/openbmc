RDEPENDS_${PN}-inventory_append_palmetto = " openpower-occ-control phosphor-webui"
RDEPENDS_${PN}-inventory_${MACHINE} += "webui-vue"

OBMC_IMAGE_EXTRA_INSTALL_append_palmetto = " mboxd"
OBMC_IMAGE_EXTRA_INSTALL_${MACHINE} += "webui-vue"
